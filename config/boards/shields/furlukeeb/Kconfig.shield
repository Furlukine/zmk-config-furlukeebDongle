## config/boards/shields/furlukeeb/Kconfig.shield
```kconfig
config SHIELD_FURLUKEEB_DONGLE
    def_bool $(shields_list_contains,FurluKeeb_dongle)
```
